# Keil uVision project KUBE2_MainFW.uvprojx, settings and files
target KUBE2_MainFW Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: KUBE2_MainFW Configuration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Include;C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/: adc.c stm32f0xx_it.c tim.c usbd_conf.c i2c.c stm32f0xx_hal_msp.c usbd_desc.c usb_device.c gpio.c usart.c
    C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c led.c btn.c barcode.c rfid.c
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_pcd.c stm32f0xx_hal_adc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_adc_ex.c
  group Middlewares/USB_Device_Library
    C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    C:/Users/kanishkaw/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 4.1.0
